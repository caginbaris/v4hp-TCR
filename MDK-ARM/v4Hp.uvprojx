# Keil uVision project v4Hp.uvprojx, settings and files
target v4Hp (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: v4Hp
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;                              ../Drivers/STM32F7xx_HAL_Driver/Inc;                              ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                              ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                              ../Drivers/CMSIS/Include;                              .\libraries;                              ..\Inc\Comm_Library_Header;                              ..\Src\Comm_Library_Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x1ffff
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: tim.c rtc.c quadspi.c dma.c stm32f7xx_hal_msp.c stm32f7xx_it.c adc.c main.c gpio.c usart.c spi.c
  group libraries
    ./libraries/: measurement_functions.c protection_functions.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group pfunctions
    ./: init_protection.c fc50.c fc50N.c fc51.c fc51N.c fc27.c fc59.c fc46.c fc49.c fcBF.c fc37.c fcUNB.c fcPVP.c pickup_handles.c
  group mfunctions
    ./: cs_handles.c trueRMS.c spectra.c
  group conversion
    ./: conversion.c
  group initFunctions
    ./: initFunctions.c
  group powerSys
    ./: powerSysData.c
  group boardIO
    ./: boardIO.c
  group Comm Layer
    ../Src/Comm_Library_Source/: CommConfig.c DataParserMerger.c fputc_debug.c Modbus_MasterSlave.c SPI_MasterSlave.c UART_MasterSlave.c
  group Comm Params
    ./: commParams.c configParams.c
  group main_flow
    ./: main_flow.c
software components: CMSIS:CORE 5.0.0
